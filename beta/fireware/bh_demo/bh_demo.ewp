# IAR project bh_demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: inc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group inc/app
    inc/: adxl345.h Config.h EEPROM.h gm8125.h gprs.h
  group inc/bsp
    inc/: bsp.h I2C.h mmc.h SPI.h
  group inc/os
    inc/: debug.h FAT.h
  group scr/app
    src/: adxl345.c EEPROM.c gm8125.c gprs.c main.c
  group scr/bsp
    src/: bsp.c I2C.c mmc.c SPI.c
  group scr/os
    src/: debug.c FAT.c
